# Keil uVision project IN-14 Nixie Clock.uvprojx, settings and files
target IN-14 Nixie Clock (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IN-14 Nixie Clock +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER\inc;..\LIB\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_conf.h
  group LIB
    ../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_rcc.c
  group USER
    ../USER/src/: main.c hv57708.c ds3231.c max1771.c systick.c led.c iic.c adc.c timer2.c timer3.c timer4.c oled.c display.c
